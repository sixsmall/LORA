# Keil uVision project huadasx1278.uvprojx, settings and files
target sx1278 (5060020::V5.06 (build 20)::ARMCC)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.2
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: huadasx1278 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __DEBUG_FLASH
  c include: .\inc;.\src;D:\keil\ARM\ARMCC\include;D:\keil\ARM\Pack\ARM;D:\keil\ARM\ARMCC_505u2\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./src/: system_hc32l110.c startup_hc32l110.s
  group Startup
    ./src/: main.c
  group Common
    ./src/: clk.c ddl.c gpio.c interrupts_hc32l110.c wdt.c spi.c lpt.c bt.c lpuart.c lpm.c key.c sx1278.c sx1278rxdelay.c flash.c
